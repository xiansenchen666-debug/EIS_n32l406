# Keil uVision project n32l406.uvprojx, settings and files
target Debug_NoBoot (6100001::V6.10.1::.\ARMCLANG)
  device: N32L406CB Nationstech
  pack: Nationstech.N32L40x_DFP.1.4.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BMSCube_N32L406
  AfterMake: fromelf --bin  -o "@L.bin" "#L"
  AfterMake: xwoda_afterbuild.bat
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: n32l40x,N32L40X, USE_STDPERIPH_DRIVER
  c include: ..\code\CMSIS\core;..\code\CMSIS;..\code\fsm;..\code\L0_SDK\inc;..\code\L1_MSP;..\code\user;..\code\L3_SSP;..\code\tool\sfud;..\code\list;..\..\CubeCommon\L1_MSP;..\..\CubeCommon\L1_MSP\ClassB;..\..\CubeCommon\L2_BSP;..\..\CubeCommon\L3_SSP;..\..\CubeCommon\TOOL\RTT;..\..\CubeCommon\TOOL;..\..\CubeCommon\rtthread;..\..\CubeCommon\rtthread\include;..\..\CubeCommon\rtthread\include\libc;..\..\CubeCommon\rtthread\components\device;..\..\CubeCommon\rtthread\components\finsh
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BMSCube_N32L406_NoBoot.sct
  group USER
    ../code/cmsis/: startup_n32l40x.s system_n32l40x.c
    ../code/user/: main.c ProjectConfig.c ProjectConfig.h BMS_DEF.h main.h
  group L0_SDK
    ../code/L0_SDK/src/: misc.c n32l40x_adc.c n32l40x_can.c n32l40x_comp.c n32l40x_crc.c n32l40x_dac.c n32l40x_dbg.c n32l40x_dma.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_iwdg.c n32l40x_lcd.c n32l40x_lptim.c n32l40x_lpuart.c n32l40x_opamp.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_spi.c n32l40x_tim.c n32l40x_tsc.c n32l40x_usart.c n32l40x_wwdg.c
  group L1_MSP
    ../../CubeCommon/L1_MSP/: MSP_ADC.c MSP_ADC.h MSP_GPIO.c MSP_GPIO.h MSP_IT.c MSP_IWTD.c MSP_IWTD.h MSP_PWM.c MSP_PWM.h MSP_SPI.c MSP_SPI.h MSP_UART.c MSP_UART.h
  group L2_BSP
    ../../CubeCommon/L2_BSP/: BSP_BQ7982X.c BSP_BQ7982X.h BSP_BQ7982X_APP.c BSP_BQ7982X_APP.h BSP_BQ7982X_DATA_TYPES.h BSP_BQ7982X_REGS.h BSP_BQ7982X_REGS_TYPES.h
  group TOOL
    ../../CubeCommon/TOOL/: lwrb.c lwrb.h
target Release (6100001::V6.10.1::.\ARMCLANG)
  device: N32L406CB Nationstech
  pack: Nationstech.N32L40x_DFP.1.4.0
  cpu: as above
  output: BMSCube_N32L406
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: n32l40x,N32L40X, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BMSCube_N32L406_NoBoot.sct
target Debug_NoBootNoClassB (6160000::V6.16::ARMCLANG)
  device: N32L406CB Nationstech
  pack: Nationstech.N32L40x_DFP.1.4.0
  cpu: as above
  output: BMSCube_N32L406 +hex
  AfterMake: fromelf --bin  -o "@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: n32l40x,N32L40X, USE_STDPERIPH_DRIVER
  c include: ..\code\CMSIS\core;..\code\CMSIS;..\code\fsm;..\code\L0_SDK\inc;..\code\L1_MSP;..\code\user;..\code\L3_SSP;..\code\tool\sfud;..\code\list;..\..\CubeCommon\L1_MSP;..\..\CubeCommon\L1_MSP\ClassB;..\..\CubeCommon\L2_BSP;..\..\CubeCommon\L3_SSP;..\..\CubeCommon\TOOL\RTT;..\..\CubeCommon\TOOL;..\..\CubeCommon\rtthread;..\..\CubeCommon\rtthread\include;..\..\CubeCommon\rtthread\include\libc;..\..\CubeCommon\rtthread\components\device;..\..\CubeCommon\rtthread\components\finsh;..\..\CubeCommon\SOC;..\..\CubeCommon\SOP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1b800
  memory RVCT9: RAM 0x20000000 size 0x6000
